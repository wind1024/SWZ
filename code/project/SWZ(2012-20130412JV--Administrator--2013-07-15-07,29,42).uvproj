# Keil uVision project SWZ(2012-20130412JV--Administrator--2013-07-15-07,29,42).uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F930 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x0FFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: SWZ
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\include;..\Libraries\inc
  asm include: ..\include
  group Source Group 1
    ./: STARTUP.A51
  group Source
    ../source/: main.c sys_about.c memory.c SWSerial.c diskio.c iic.c Acceleration.c AT_Commands.c ZigBee.c number_operation.c calculate.c
  group Libraries
    ../Libraries/src/: C8051f93x_SysClk.c SmaRTClock.c power.c C8051f93x_IOPort.c C8051f93x_UART0.c C8051f93x_Timer01.c C8051f93x_Timer23.c C8051f93x_ADC.c
